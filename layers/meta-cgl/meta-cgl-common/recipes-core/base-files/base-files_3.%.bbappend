dirs755-lsb += "/etc/profile.d/"
