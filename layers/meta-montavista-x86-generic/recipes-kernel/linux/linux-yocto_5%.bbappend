FILESEXTRAPATHS_prepend := "${THISDIR}/linux-mvista:"
SRC_URI += "file://defconfig"

COMPATIBLE_MACHINE_x86-generic-64 = "x86-generic-64"
COMPATIBLE_MACHINE_x86-generic = "x86-generic"
COMPATIBLE_MACHINE_x86-atom-64 = "x86-atom-64"
COMPATIBLE_MACHINE_corei7-mrsv-64 = "corei7-mrsv-64"
COMPATIBLE_MACHINE_dsu-d5-64 = "dsu-d5-64"

